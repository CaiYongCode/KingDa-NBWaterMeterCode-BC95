/*********************************************************************************
文件包含区
*********************************************************************************/
#include "Globaldata.h"
/*********************************************************************************
常量定义区
*********************************************************************************/
/*********************************************************************************
公共变量定义区
*********************************************************************************/
RTC_TimeTypeDef   RTC_TimeStr;        //RTC时间结构体
RTC_DateTypeDef   RTC_DateStr;        //RTC日期结构体
struct Meter_Parameter_EN MeterParameter;
struct History_Data_EN HistoryData;
/*********************************************************************************
外部变量声明区
*********************************************************************************/

/*********************************************************************************
私有变量定义区
*********************************************************************************/ 
/*********************************************************************************
测试变量定义区
*********************************************************************************/
/*********************************************************************************
内部函数定义区
*********************************************************************************/
/*********************************************************************************
功能代码定义区
*********************************************************************************/
unsigned char Int_to_ASCLL(unsigned char data)
{
  unsigned char value = 0;
  
  if( data <= 9 )
  {
          value = data + '0';
  }
  else
  {
          value = data + 'A' - 10;
  }
  return value;
}

/*********************************************************************************
 Function:      //
 Description:   //
 Input:         //
                //
 Output:        //
 Return:      	//
 Others:        //
*********************************************************************************/
unsigned char ASCLL_to_Int(unsigned char data)
{
  unsigned char value = 0;
  if(data >= '0' && data <= '9')
    value = data - '0';
  else if(data >= 'A' && data <= 'F')
    value = data - 'A' + 10;
  else if(data >= 'a' && data <= 'f')
    value = data - 'a' + 10;
  else value = data;
  return value;
}
/*********************************************************************************
 Function:      //
 Description:   //
 Input:         //
                //
 Output:        //
 Return:      	//
 Others:        //
*********************************************************************************/
unsigned char BCD_to_Int(unsigned char data)
{
  return (data/16*10+data%16);
}

/*********************************************************************************
 Function:      //
 Description:   //
 Input:         //
                //
 Output:        //
 Return:      	//
 Others:        //
*********************************************************************************/
void delay_ms(u16 time)
{    
   u16 i=0;  
   while(time--)
   {
      i=16000;  //自己定义
      while(i--) ;    
   }
}
/*********************************************************************************
 Function:      //
 Description:   //
 Input:         //
                //
 Output:        //
 Return:      	//
 Others:        //
*********************************************************************************/

/*********************************************************************************
 Function:      //
 Description:   //
 Input:         //
                //
 Output:        //
 Return:      	//
 Others:        //
*********************************************************************************/

