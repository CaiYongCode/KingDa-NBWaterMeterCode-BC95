# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\BSP; ..\inc; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group BSP
    ../BSP/: BC95.c BC95.h mcu_init.c mcu_init.h Sys_Timer.c Sys_timer.h Temperature.c Temperature.h
  group Lib
    ../src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group Protocol
    ../USER/: CJT-188-2004.c CJT-188-2004.h protocol.c protocol.h
  group USER
    ../USER/: Globaldata.c Globaldata.h include.h main.c main.h Pulse_Acquire.c Pulse_Acquire.h rtc.c rtc.h Save.c save.h stm8l15x_it.c uart.c uart.h
