# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\APP\inc; ..\BSP\inc; ..\LIB\inc; ..\USER\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    ../APP/src/: data_process.c debug.c soft_timer.c uplink_protocol.c
    ../APP/inc/: data_process.h debug.h soft_timer.h uplink_protocol.h
  group BSP
    ../BSP/src/: bc95.c common.c detect.c flash.c mcu.c pulse.c rtc.c usart.c
    ../BSP/inc/: bc95.h common.h detect.h flash.h mcu.h pulse.h rtc.h usart.h
  group LIB
    ../LIB/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim4.c stm8l15x_usart.c
  group USER
    ../USER/inc/: include.h
    ../USER/src/: main.c stm8l15x_it.c
